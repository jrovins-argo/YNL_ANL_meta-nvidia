include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

LIC_FILES_CHKSUM = "file://../LICENSE;md5=2cc00be68c1227a7c42ff3620ef75d05"

SRC_URI[md5sum] = "d459669e933054d65142799b82441263"
SRC_URI[sha256sum] = "4856386f70eb8e73444016f631d4079e3dabe4828483b932405f3b24e6f0b70d"

