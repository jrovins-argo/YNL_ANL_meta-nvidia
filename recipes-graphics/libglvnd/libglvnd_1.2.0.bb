include libglvnd.inc

# v1.2.0 tag
SRCREV = "062a42ea55a9452bfcfe6268348a82edbea7542c"
